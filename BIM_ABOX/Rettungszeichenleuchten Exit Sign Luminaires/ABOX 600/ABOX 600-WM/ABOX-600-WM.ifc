Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: edf84a68-4f35-48fa-ba28-5ee0bf4e2c07, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: 2018_01
Time: 2024-02-27T10:49:46+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.1.24 - Exporter 23.2.1.0 - Alternativ-UI 23.2.1.0

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ABOX-600-WM:ABOX 600 WM, ABOX-600-WM:ABOX 600 WM:2487294
In: Default
Type - Material: Aluminium Profil, Kunststoff - PMMA, Kunststoff -PVC, RAL 7047
Type - Pset_ElementShading - Color: white
Material: RAL 7047
Pset_DistributionFlowElementCommon - Reference: ABOX 600 WM; sets with these values: 2
