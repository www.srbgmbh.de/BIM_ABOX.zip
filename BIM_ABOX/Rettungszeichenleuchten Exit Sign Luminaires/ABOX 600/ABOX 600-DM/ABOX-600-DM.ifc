Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 72aa2054-7032-4247-a96b-265a39c40c8e, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: 2018_01
Time: 2024-02-27T10:40:09+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.1.24 - Exporter 23.2.1.0 - Alternativ-UI 23.2.1.0

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ABOX-600-DM:ABOX-600-DM, ABOX-600-DM:ABOX-600-DM:2491674
In: Default
Type - Material: Glatt - Weiß, Milchig
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: ABOX-600-DM; sets with these values: 2
