Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 4ea48d26-c87b-41e6-9c18-f02878e651f2, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: 2018_01
Time: 2024-02-27T08:21:40+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.1.24 - Exporter 23.2.1.0 - Alternativ-UI 23.2.1.0

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ABOX-200-DM:ABOX-200-DM, ABOX-200-DM:ABOX-200-DM:2491674
In: Default
Type - Material: 6060-T6(1)
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: ABOX-200-DM; sets with these values: 2
