Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 0c68618f-cd14-4291-83da-a3e9d4891419, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: 2018_01
Time: 2024-02-27T08:46:50+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.1.24 - Exporter 23.2.1.0 - Alternativ-UI 23.2.1.0

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ABOX-200-WM:ABOX 200 WM, ABOX-200-WM:ABOX 200 WM:2487301
In: Default
Type - Material: Aluminium Profil, Kunststoff - PMMA, Kunststoff -PVC, 6060-T6(1)
Type - Pset_ElementShading - Color: white
Material: 6060-T6(1)
Pset_DistributionFlowElementCommon - Reference: ABOX 200 WM; sets with these values: 2
