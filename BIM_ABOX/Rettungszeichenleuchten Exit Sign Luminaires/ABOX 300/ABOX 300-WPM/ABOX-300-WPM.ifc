Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 4910b041-c0bf-4c8c-8715-2f962abb4496, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: 2018_01
Time: 2024-02-27T09:50:31+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.1.24 - Exporter 23.2.1.0 - Alternativ-UI 23.2.1.0

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ABOX-300-WPM:ABOX 300 WPM, ABOX-300-WPM:ABOX 300 WPM:2487293
In: Default
Type - Material: Glatt - weiß, Milchig
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: ABOX 300 WPM; sets with these values: 2
