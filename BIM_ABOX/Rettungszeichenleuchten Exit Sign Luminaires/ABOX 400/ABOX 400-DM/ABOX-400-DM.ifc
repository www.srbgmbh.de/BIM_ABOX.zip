Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: f36f25cb-12b4-4989-8afa-8069785f58e0, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: 2018_01
Time: 2024-02-27T10:07:38+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.1.24 - Exporter 23.2.1.0 - Alternativ-UI 23.2.1.0

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ABOX-400-DM:ABOX-400-DM, ABOX-400-DM:ABOX-400-DM:2491674
In: Default
Type - Material: 6060-T6(1), Milchig
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: ABOX-400-DM; sets with these values: 2
