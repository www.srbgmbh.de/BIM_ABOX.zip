Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: fd440f2c-8a1c-4e0d-ba1f-821cc7cb7399, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: ABOX-400-WPM.ifc
Time: 2024-11-07T07:50:22+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ABOX-400-WPM:ABOX 400 WPM, ABOX-400-WPM:ABOX 400 WPM:2518124
In: Default
Type - Material: Aluminium Profil, Kunststoff - PMMA, Kunststoff -PVC, Glatt - weiß
Type - Pset_ElementShading - Color: white
Material: Glatt - weiß, Milchig
Pset_DistributionFlowElementCommon - Reference: ABOX 400 WPM; sets with these values: 2
